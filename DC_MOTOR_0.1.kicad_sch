File: DC_MOTOR_0.1.kicad_sch (KiCad schematic)
At the start: 17 parts, among them P15 Pad, P17 Pad

Commit message: zmiana 1
Parts:
- renumbered P15 to P10, P17 to P9
